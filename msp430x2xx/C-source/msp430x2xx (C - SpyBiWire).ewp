# IAR project msp430x2xx (C - SpyBiWire).ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2001 MSP430F2001
  General.GStackSize2: 50
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2001.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ./: msp430x2xx_fet_1.c
