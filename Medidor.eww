<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\msp430x2xx\C-source\msp430x2xx (C).ewp</path>
  </project>
  <batchBuild/>
</workspace>


